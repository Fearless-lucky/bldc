# Keil uVision project TASK1.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TASK1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Device\StdPeriph_Driver\inc;.\Core\Include;.\Core\Source;.\Device\StdPeriph_Driver\src;.\Device\StdPeriph_Driver\templates;.\crouse.c;.\crouse.h;.\freertos\include;.\freertos\portable;.\freertos\src;.\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group .c
    ./Device/StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_i2c.c misc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group .h
    ./Device/StdPeriph_Driver/inc/: stm32f10x_usart.h stm32f10x_spi.h misc.h stm32f10x_i2c.h stm32f10x_dma.h stm32f10x_can.h stm32f10x_fsmc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_tim.h stm32f10x_wwdg.h
    ./Device/StdPeriph_Driver/templates/: stm32f10x_conf.h
  group startup
    ./Device/Source/ARM/: startup_stm32f10x_hd.s
    ./Device/Source/: system_stm32f10x.c
  group myinclude
    ./: delay.c key.c svpwm.c svpwm_main.c svpwm_tim.c sys.c uart_cmd.c trajectory.c sorter.c bldc.c conveyor.c
  group mysrc
    ./: delay.h key.h stm32f10x_conf.h svpwm.h svpwm_tim.h sys.h uart_cmd.h trajectory.h sorter.h bldc.h conveyor.h
